# Keil uVision project tutorial.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tutorial
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: tutorial.c MyLCD.c MyLCD.h MyAccelerometer.c MyAccelerometer.h
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX 4.81.1, Compiler:I/O:STDERR 1.2.1, Compiler:I/O:STDIN 1.2.1, Compiler:I/O:STDOUT 1.2.1, Board Support:Graphic LCD 2.0.0, CMSIS Driver:I2C 2.1, CMSIS Driver:SPI 2.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0
